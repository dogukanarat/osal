## zephyr/Kconfig
```kconfig
config OSAL
    bool "OS Abstraction Layer"
    default y
    help
      Enable the OSAL library for Zephyr.
```
